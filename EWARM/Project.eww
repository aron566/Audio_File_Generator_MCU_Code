<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F407VET6_Audio_Tool.ewp</path>
  </project>
  <batchBuild />
</workspace>
